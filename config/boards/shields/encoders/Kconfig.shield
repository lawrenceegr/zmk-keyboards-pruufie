## config/boards/shields/pruufie/Kconfig.defconfig
```kconfig
if SHIELD_PRUUFIE

config ZMK_KEYBOARD_NAME
	default "Pruufie"

endif # SHIELD_PRUUFIE
```
